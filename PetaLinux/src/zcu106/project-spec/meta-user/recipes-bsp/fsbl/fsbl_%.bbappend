
YAML_COMPILER_FLAGS_append = " -DXPS_BOARD_ZCU106"
