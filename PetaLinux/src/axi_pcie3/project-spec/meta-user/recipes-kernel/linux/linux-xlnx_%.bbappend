SRC_URI += "file://kernel-options.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

