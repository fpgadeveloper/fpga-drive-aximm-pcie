SRC_URI += "file://user.cfg \
            file://kernel-options.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

