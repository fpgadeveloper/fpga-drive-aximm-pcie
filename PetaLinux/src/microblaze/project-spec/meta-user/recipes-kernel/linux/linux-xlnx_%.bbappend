SRC_URI += "file://user.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

