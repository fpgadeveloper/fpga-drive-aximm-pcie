SRC_URI += "file://user.cfg \
            file://kcu105.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

