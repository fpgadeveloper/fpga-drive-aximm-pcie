FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-xlnx-scr:"

SRC_URI:append = " file://boot.cmd.generic"
