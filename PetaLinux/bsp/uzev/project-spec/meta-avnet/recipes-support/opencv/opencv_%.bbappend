PACKAGECONFIG:append = " libav "

