FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

UBOOTELF_NODTB_BINARY = "u-boot.elf"
