FILESEXTRAPATHS:prepend:u96v2-sbc := "${THISDIR}/files:"

INITSCRIPT_PARAMS:u96v2-sbc = "start 03 2 3 4 5 . stop 80 0 6 1 ."
