DESCRIPTION = "OSL image definition for Avnet boards"
LICENSE = "MIT"

require avnet-image-full.inc
