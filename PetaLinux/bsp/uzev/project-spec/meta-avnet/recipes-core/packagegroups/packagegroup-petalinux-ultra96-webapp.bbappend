ULTRA96_STARTUP_PAGES_PACKAGES:remove = " \
	chromium-x11 \
	"
